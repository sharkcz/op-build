## openpower/package/pnv-lpc/Config.in
```kconfig
config BR2_PACKAGE_PNV_LPC
	bool "pnv-lpc"
	default n
	help
	  Build and install PowerNV LPC debug utility
```
